# Keil uVision project F103KIT_1963.uvproj, settings and files
target F103KIT_1963 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103KIT_1963 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src;..\USER\main;..\USER\GUI;..\USER\GUI\inc;..\USER\GUI_DIALOG;..\USER\SDCARD;..\USER\FatFS;..\USER\FatFS\option;..\USER\TSC2046;..\USER\Fonts;..\USER\MX25L8005;..\USER\ssd1963;..\USER\icons;..\USER\tjpgd1b\src;..\USER\bxCAN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group cmsis
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group main
    ../USER/main/: main.c stm32f10x_it.c template.c header.h
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_exti.c
  group MX25l8005
    ../USER/MX25L8005/: mx25l8005.c
  group SSD1963
    ../USER/ssd1963/: ssd1963_lcd.c
  group Fonts
    ../USER/Fonts/: Arial16.c
  group GUI
    ../USER/GUI/: GUI_X.c GUIConf.c LCDConf.c STemWin522_CM3_Keil.lib
  group GUI_DIALOG
    ../USER/GUI_DIALOG/: ALARMDLG.c KEYDLG.c MENUDLG.c PictureView.c SD_File.c Start_WindowDLG.c TIME_DATEDLG.c TIMERDLG.c
  group SDCARD
    ../USER/SDCARD/: sdcard.c
  group FatFS
    ../USER/FatFS/: diskio.c ff.c
    ../USER/FatFS/option/: ccsbcs.c
  group TjpgDec
    ../USER/tjpgd1b/src/: tjpg_lib.c tjpgd.c tjpgd.h
  group TSC2046
    ../USER/TSC2046/: tsc2046.c
  group Icons
    ../USER/icons/: add_folder.c alarm.c alarm_d.c AlarmA.c AlarmB.c bmp.c date.c del_folder.c exit.c gif.c hourglass.c jpg.c next.c paint.c pdf.c photo.c prev.c pwm.c screen.c sd.c
  group bxCAN
    ../USER/bxCAN/: CAN.c
